# Keil uVision project Shed.uvproj, settings and files
target Shed (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT91SAM7X256 Microchip
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: Shed
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Src
    ./: SAM7.s defines.s main.c util.s
